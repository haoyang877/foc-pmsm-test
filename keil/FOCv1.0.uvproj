# Keil uVision project FOCv1.0.uvproj, settings and files
target FOC1.0 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FOCv1.0
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_HD
  c include: ..\stm_lib\STM32F10x_StdPeriph_Driver\inc;..\app\inc;..\stm_lib\CMSIS\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Scource
    ../app/scr/: main.c MC_Clarke_Park.c MC_Display.c MC_FOC_Drive.c MC_Globals.c MC_Keys.c MC_MotorControl_Layer.c MC_PID_regulators.c stm32_2.8_lcd.c stm32f10x_encoder.c stm32f10x_it.c stm32f10x_svpwm_3shunt.c stm32f10x_Timebase.c usart.c hall.c
  group stm_lib
    ../stm_lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group asm
    ../stm_lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../stm_lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../stm_lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
